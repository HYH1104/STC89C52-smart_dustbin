# Keil uVision project YS-V0.7.uvproj, settings and files
target 语音识别操作IO (MCS-51)
  device: STC11F02E STC
  cpu: IRAM(0-0xFF) IROM(0-0x7FF) CLOCK(45000000)
  output: 语音识别操作IO +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\code;..\user
  group APP
    ../code/: main.c LDChip.c Reg_RW.c
  group Driver
    ../user/: usart.c
